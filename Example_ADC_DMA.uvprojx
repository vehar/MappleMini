# Keil uVision project Example_ADC_DMA.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Example_ADC_DMA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\stm_lib\inc;.\cmsis;.\STM32_USB-FS-Device_Lib;.\syscalls;.\MinGW_Lib;.\nrf24l01;.\nrf24l01p;.\cmsis_boot;..\Project VCP + nRF24;.\;.\cmsis\DeviceSupport\ST\STM32F10x\startup\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: A:\VCP_ADC_out\Example_ADC_DMA.sct
  group main
    ./: hw_config.c main.c stm32_it.c
  group cmsis
    ./cmsis/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group cmsis_boot
    ./cmsis_boot/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
    ./cmsis_boot/startup/: startup_stm32f10x_md.c
  group stm_lib
    ./stm_lib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
    ./stm_lib/inc/: misc.h stm32f10x_adc.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_gpio.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_spi.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_wwdg.h
  group STM32_USB-FS-Device_lib
    ./STM32_USB-FS-Device_Lib/: usb_conf.h usb_core.c usb_core.h usb_def.h usb_desc.c usb_desc.h usb_endp.c usb_init.c usb_init.h usb_int.c usb_int.h usb_istr.c usb_istr.h usb_lib.h usb_mem.c usb_mem.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
  group sturtup
    ./cmsis/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
